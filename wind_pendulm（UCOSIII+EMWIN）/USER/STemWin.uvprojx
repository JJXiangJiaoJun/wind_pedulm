# Keil uVision project STemWin.uvprojx, settings and files
target STemWin MCULCD (ARM-ADS)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SDRAM;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\HARDWARE\MPU;..\USMART;..\MALLOC;..\DSP_LIB\Include;..\UCOSIII\uC-LIB;..\UCOSIII\uC-CPU;..\UCOSIII\UCOS-BSP;..\UCOSIII\UCOS-CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\EMWIN_DEMO\TEXT_DISPLAY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_qspi.c stm32f7xx_hal_nand.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: ltdc.c tftlcd.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c touch.c ft5206.c gt9147.c ott2001a.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/NAND/: ftl.c nand.c nandtester.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM7lfsp_math.lib
  group FATFS
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
    ../FATFS/src/: diskio.c ff.c
  group TEXT
    ../TEXT/: fontupd.c mytext.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS-BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_str.c lib_ascii.c lib_math.c lib_mem.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/UCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: GUI_CM4F_L.lib
  group EMWIN_CONFIG
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_Lin_Template.c LCDConf_FlexColor_Template.c GUIConf.h
    ../EMWIN/STemWin/OS/: GUI_X_UCOSIII.c
  group EMWIN_HZ
    ../EMWIN/STemWinHZ/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_FontHZ32.c GUI_UC_EncodeNone.c GUICharPEx.c Hzfontupdata.c
  group EMWIN_TASK
    ../EMWIN_TASK/TEXT_DISPLAY/: textdisplay.c
    ../EMWIN_TASK/ICONVIEW/: myiconview.c
    ../EMWIN_TASK/EMWIN_PICTURE/BMP/: bmpdisplay.c
    ../EMWIN_TASK/EMWINFONT/: xbffontcreate.c
    ../EMWIN_TASK/GUI_BUILDER/: myframe.c buttonbmp.c
  group MOTOR
    ../MOTOR/: motor_control.c motor_pid.c motor_pwm.c
  group MALLOC
    ../MALLOC/: malloc.c
  group TASK
    ../TASK/ANGLETASK/: angletask.c
    ../TASK/LEDTASK/: ledtask.c
    ../TASK/UPDATEFONTTASK/: updatefont.c
  group NIMING
    ../HARDWARE/NIMING/: niming.c
  group README
    ../: readme.txt
target STemWin RGBLCD (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: as above
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c misc: --locale=english
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\SDRAM;..\HARDWARE\LCD;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\MPU;..\USMART;..\MALLOC;..\DSP_LIB\Include;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\UCOS-BSP;..\UCOSIII\UCOS-CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\TIMER;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\MOTOR;..\EMWIN_TASK\GUI_BUILDER;..\EMWIN_TASK\TEXT_DISPLAY;..\TASK\ANGLETASK;..\TASK\LEDTASK;..\TASK;..\TASK\ADCSHOWTASK;..\TASK\LCDTASK;..\TASK\TESTTASK;..\EMWIN_TASK\ICONVIEW;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\EMWIN\STemWinHZ;..\TASK\UPDATEFONTTASK;..\EMWIN_TASK\EMWIN_PICTURE\BMP;..\EMWIN_TASK\EMWINFONT;..\HARDWARE\NIMING
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
